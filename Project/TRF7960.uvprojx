# Keil uVision project TRF7960.uvprojx, settings and files
target TRF7970 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TRF7960 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\User;..\Libraries\CMSIS;..\Libraries\FWlib\inc;..\Libraries\CMSIS\startup;..\User\systick;..\User\TRF7970WX
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group RFID
    ../User/TRF7970WX/: felica.c highdata.c host.c initiator.c iso14443a.c iso14443b.c iso15693.c nfc.c parallel.c spi.c tag.c target.c trf797x.c type2.c uart.c
  group USER
    ../User/: main.c stm32f10x_it.c sysinit.c sysinit.h stm32f10x_conf.h
  group FWLB
    ../Libraries/FWlib/src/: misc.c stm32f10x_can.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group TXT
    ../Doc/: readme.txt
